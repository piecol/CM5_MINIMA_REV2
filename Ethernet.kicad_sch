File: Ethernet.kicad_sch (KiCad schematic)
At the start: 7 parts, among them T401 7498111120AR, U401 TPD4EUSB30, U402 TPD4EUSB30

Commit message: power symbols
Connections:
- net 3V3 renamed +3V3_PI
