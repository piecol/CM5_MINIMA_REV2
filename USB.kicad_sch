File: USB.kicad_sch (KiCad schematic)
At the start: 9 parts, among them U701 AP22653W6

Commit message: power symbols
Connections:
- net 5V renamed +5V
- net VBUS renamed VBUS_USB2.0
